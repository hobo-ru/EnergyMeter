<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\PM_Boot\iar\bl-usart-happy.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pm2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


