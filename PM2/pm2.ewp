# IAR project pm2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32HG222F64 SiliconLaboratories EFM32HG222F64
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: EFM32HG222F64; __arm__; noCHECK_POWERLINE_FAKE; noFORCE_CALIBRATION; nVER_3_0; nVER_2_3; VER_SPLIT; nCURRENT_80
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\; $TOOLKIT_DIR$\CMSIS\Include; Src\; Libs\emlib\inc; Libs\emdrv\Sleep\inc; Libs\emdrv\gpiointerrupt\inc; Libs\EFM32HG\Include; Libs\u8glib\csrc\; Libs\FreeRTOS\Source\include; Libs\glcd; Libs\FreeRTOS\Source\portable\IAR\ARM_CM0; Libs\m2tk_u8g\src; Libs\libtd1202\inc; Src\modem; Src\meter; Src\archive; Src\DTI
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Libs\FreeRTOS\Source\include; Src\; Libs\emlib\inc
  OBJCOPY.OOCOutputFile: pm2.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: EFM32HG222F64.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group Libs/core
    Libs/EFM32HG/Source/IAR/: startup_efm32hg.c
    Libs/EFM32HG/Source/: system_efm32hg.c
  group Libs/emdrv
    Libs/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    Libs/emdrv/sleep/src/: sleep.c
  group Libs/emlib
    Libs/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group Libs/libtd1202
    Libs/libtd1202/src/: td_measure.c td_rtc.c
    Libs/libtd1202/inc/: td_measure.h
  group Libs/m2tklib
    Libs/m2tk_u8g/src/: chessengine.c m2.c m2.h m2align.c m2dfs.c m2draw.c m2eh2bd.c m2eh2bs.c m2eh4bd.c m2eh4bs.c m2eh6bs.c m2ehts.c m2el2lmenu.c m2elalign.c m2elbutton.c m2elbuttonptr.c m2elcombo.c m2elcombofn.c m2elcomboptr.c m2elfnfmt.c m2elhide.c m2elinfo.c m2ellabel.c m2ellabelfn.c m2ellabelp.c m2ellabelptr.c m2ellistbase.c m2ellistcalc.c m2ellistgrid.c m2ellisth.c m2ellistv.c m2ellistxy.c m2elradio.c m2elroot.c m2els8base.c m2els8num.c m2elsb.c m2elsetval.c m2elslbase.c m2elspace.c m2elstr.c m2elstrlist.c m2elstrptr.c m2elstrup.c m2elsubutl.c m2eltext.c m2eltoggle.c m2eltsk.c m2elu32.c m2elu8base.c m2elu8hs.c m2elu8num.c m2elxbm.c m2esavru8g.c m2fnarg.c m2gfx.c m2gfxutl.c m2ghdummy.c m2ghu8g.h m2ghu8gbf.c m2ghu8gbfs.c m2ghu8gcffs.c m2ghu8gfb.c m2ghu8gffs.c m2ghu8gicon.c m2ghu8gutl.c m2key.c m2msg.c m2navdatadn.c m2navdataup.c m2navfirst.c m2navinit.c m2navlast.c m2navnext.c m2navprev.c m2navroot.c m2navupdn.c m2navutl.c m2null.c m2obj.c m2opt.c m2pin.c m2qk.c m2rom.c m2usrnext.c m2usrprev.c m2usrupdn.c m2utl.h m2utls8d.c m2utlstrdat.c m2utlu8d.c
  group Libs/u8glib
    Libs/u8glib/csrc/: u8g.h u8g_bitmap.c u8g_circle.c u8g_clip.c u8g_com_api.c u8g_com_io.c u8g_com_null.c u8g_cursor.c u8g_delay.c u8g_dev_st7565_lm6059.c u8g_ellipse.c u8g_font.c u8g_line.c u8g_ll_api.c u8g_page.c u8g_pb.c u8g_pb14v1.c u8g_pb16h1.c u8g_pb16h2.c u8g_pb16v1.c u8g_pb16v2.c u8g_pb32h1.c u8g_pb8h1.c u8g_pb8h1f.c u8g_pb8h2.c u8g_pb8h8.c u8g_pb8v1.c u8g_pb8v2.c u8g_pbxh16.c u8g_pbxh24.c u8g_polygon.c u8g_rect.c u8g_scale.c u8g_state.c u8g_u16toa.c u8g_u8toa.c
    Libs/u8glib/sfntsrc/: u8g_font_data.c
  group Src
    Src/: display.c display.h gui.c main.c main.h mqueue.c mqueue.h pwr_managment.c pwr_managment.h scheduler.c scheduler.h sensors_external.c sensors_external.h systimer.c systimer.h tariff.c tariff.h timeevents.c timeevents.h triggersevents.c triggersevents.h u8g_arm.c u8g_arm.h
  group Src/archive
    Src/archive/: archive.c archive.h at25sf041.c at25sf041.h
    Src/meter/: meter_archive.c meter_archive.h
  group Src/DTI
    Src/DTI/: dti.c dti.h leuart.c leuart.h
  group Src/HW_defines
    Src/: defines_HW.h defines_VER_100.h defines_VER_103.h defines_VER_110_split.h defines_VER_300.h
  group Src/meter
    Src/meter/: ade7868a.c ade7868a.h ade7953.c ade7953.h meter.c meter.h meterage.c meterage.h
  group Src/modem
    Src/modem/: electro_v5.c electro_v5.h modem.c modem.h modem_uart.c modem_uart.h
