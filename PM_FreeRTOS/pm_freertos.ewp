# IAR project pm_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32G210F128 SiliconLaboratories EFM32G210F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32G210F128; IAR_ARM_CM3; DEBUG_EFM
  ICCARM.CCIncludePath2: FreeRTOS\Source\include; ; emlib\inc; emdrv\inc; EFM32G\Include; bsp; u8glib; $TOOLKIT_DIR$\; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: FreeRTOS\Source\include; ; emlib\inc
  OBJCOPY.OOCOutputFile: pm_freertos.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: pm_freertos.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: energy_meter.c glcd.c irq_handlers.c low_power_tick_management.c main.c semtech.c stlcd.c unb.c
  group bsp
    bsp/: bsp_trace.c
  group core
    EFM32G/Source/IAR/: startup_efm32g.c startup_efm32g.s
    EFM32G/Source/: system_efm32g.c
  group emdrv
    emdrv/src/: sleep.c
  group emlib
    emlib/src/: em_adc.c em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_rmu.c em_rtc.c em_system.c em_timer.c
  group FreeRTOS
    FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    FreeRTOS/Source/portable/MemMang/: heap_1.c
    FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group u8glib
    u8glib/: u8g_bitmap.c u8g_circle.c u8g_clip.c u8g_com_api.c u8g_com_null.c u8g_delay.c u8g_dev_st7565_dogm128.c u8g_font.c u8g_font_data.c u8g_line.c u8g_ll_api.c u8g_page.c u8g_pb.c u8g_pb8v1.c u8g_rect.c u8g_state.c u8g_virtual_screen.c
