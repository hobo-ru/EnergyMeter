# IAR project bl-usart-happy.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32HG222F64 SiliconLaboratories EFM32HG222F64
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: EFM32HG222F64; NDEBUG
  ICCARM.CCIncludePath2: ..\Libs\CMSIS\Include; ..\Libs\EFM32HG\Include; ..\src; ..\Libs\emlib\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32HG\Include; ..\src
  OBJCOPY.OOCOutputFile: pm2_bl.hex
  ILINK.IlinkOutputFile: bl-usart-happy.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: EFM32HG108F32 SiliconLaboratories EFM32HG108F32
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; EFM32HG108F32; ##bootloader-version-string##
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: bl-usart-happy.bin
  ILINK.IlinkIcfFile: ..\src\bootloader.icf
  group Source
    ../src/: at25sf041.c at25sf041.h autobaud.c boot.c bootloader.c crc.c debug.c debuglock.c flash.c iarwrite.c leuart.c startup_efm32.s xmodem.c
  group Source/Libs/emlib
    ../Libs/emlib/src/: em_cmu.c em_gpio.c
